# Keil uVision project kylinbot.uvprojx, settings and files
target kylinbot (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: kylinbot +hex
  AfterMake: fromelf.exe  --bin -o ../bin/kylinbot.bin ./Objects/kylinbot.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F427X,STM32F427xx
  c misc: --C99
  c include: ..\..\stl\CMSIS\core;..\..\stl\CMSIS\device;..\..\stl\StdPeriph_Driver\inc;..\..\stl\inc;..\..\bsp\inc;..\..\srv\inc;..\..\asp\inc;..\..\app\inc;..\..\usr\inc;..\..\kos\inc;..\..\drv\inc;..\..\stl\inc;..\..\hal\inc
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group usr/src
    ../../usr/src/: main.c stm32f4xx_it.c
  group bsp/src
    ../../bsp/src/: can1.c can2.c beep.c led.c usart2.c usart3.c tim.c usart6.c
  group drv/src
    ../../drv/src/: delay.c flash.c control.c motor.c
  group stl/src
    ../../stl/StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmip2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../stl/src/: system_stm32f4xx.c
    ../../stl/src/arm/: startup_stm32f427xx.s
